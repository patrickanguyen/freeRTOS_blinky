# Keil uVision project freeRTOS_blinky.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freeRTOS_blinky
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c bsp.c bsp.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, Device:Startup 1.0.1
